AREA reset,DATA,READONLY
	EXPORT __Vectors
__Vectors
	DCD 0x10001000
	DCD Reset_Handler
	ALIGN
	AREA mycode,CODE,READONLY
	EXPORT Reset_Handler
	ENTRY
Reset_Handler
	MOV R4,#0
	MOV R1,#10
	LDR R0,=LIST
	LDR R2,=RESULT
	MOV R6,#0
UP
	LDR R3,[R0,R4]
	STR R3,[R2,R4]
	ADD R4,#4
	SUBS R1,#1
	BNE UP
	LDR R0,=RESULT
	MOV R3,#10
	SUB R3,#1
	MOV R10,#0
	MOV R9,R3
	MOV R5,R0
OUTER_LOOP
	MOV R4,R3
	MOV R10,R5
	ADD R10,#4
	MOV R11,R5
INNER_LOOP
	LDR R6,[R11]
	LDR R7,[R10]
	CMP R7,R6
	BHS COMPL
	MOV R11,R10
COMPL
	ADD R10,#4
	SUBS R4,R4,#1
	BNE INNER_LOOP
	LDR R8,[R5]
	LDR R12,[R11]
	STR R12,[R5]
	STR R8,[R11]
	SUB R3,#1
	SUBS R9,R9,#1
	ADD R5,#4
	BNE OUTER_LOOP
STOP
	B STOP
LIST DCD 0x09,0x23,0x27,0x34,0x3,0x81,0x42,0x21,0x7,0x27
	AREA data,DATA,READWRITE
RESULT DCD 0x0
	END